# Keil uVision project Project.uvprojx, settings and files
target STM32F429I_DISCO_MB1075 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I_DISCO_MB1075
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F429xx,USE_STM32F429I_DISCO
  c include: ..\Inc;D:\STM32Cube\Repository\STM32Cube_FW_F4_V1.11.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;D:\STM32Cube\Repository\STM32Cube_FW_F4_V1.11.0\Drivers\CMSIS\Include;D:\STM32Cube\Repository\STM32Cube_FW_F4_V1.11.0\Drivers\STM32F4xx_HAL_Driver\Inc;D:\STM32Cube\Repository\STM32Cube_FW_F4_V1.11.0\Drivers\BSP\STM32F429I-Discovery;D:\STM32Cube\Repository\STM32Cube_FW_F4_V1.11.0\Middlewares\ST\STemWin\inc
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM324x9I_DISCO
    D:/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_ts.c stm32f429i_discovery_sdram.c stm32f429i_discovery_io.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Middlewares/STemWin/Lib
    D:/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Middlewares/ST/STemWin/Lib/: STemWin528_CM4_Keil.lib
  group Drivers/BSP/Components
    D:/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/BSP/Components/stmpe811/: stmpe811.c
    D:/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/BSP/Components/ili9341/: ili9341.c
  group Middlewares/STemWin/Config
    D:/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: LCDConf_stm32f429i_disco_MB1075.c GUIConf.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: BASIC_HelloWorld.c stm32f4xx_it.c main.c delay.c mstimer.c main_entry.c hub75.c
  group Drivers/STM32F4xx_HAL_Driver
    D:/STM32Cube/Repository/STM32Cube_FW_F4_V1.11.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c
software components: CMSIS:CORE 4.1.0
